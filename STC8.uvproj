# Keil uVision project STC8.uvproj, settings and files
target STC8G (MCS-51)
  device: STC8G2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC8G = 1, STC8H = 0, STC8A = 0
  c include: ..\STC8H;.\STC8\lq_stc8;.\STC8\peripheral;.\STC8\test;.\STC8\other
  group main
    ./: main.c irq.c main.h stc8.h
  group peripheral
    ./STC8/peripheral/: lq_led.c lq_oled.c lq_mpu6050.c lq_icm20602.c lq_9ax.c ANO_DT.c lq_key.c
  group lq
    ./STC8/lq_stc8/: lq_adc.c lq_adc.h lq_enc.c lq_enc.h lq_gpio.c lq_gpio.h lq_pwm.c lq_pwm.h lq_spi.c lq_spi.h lq_timer.c lq_timer.h lq_uart.c lq_uart.h lq_softiic.c lq_softiic.h lq_eeprom.c lq_eeprom.h
  group other
    ./STC8/other/: PID.c Value.c eeprom.c Enc.c filter.c Motor.c BLE.c ADC.c CCD.c
target STC8H (MCS-51)
  device: STC8G2K64S4 STC
  cpu: as above
  output: STC8 +hex
  c flags: Optimize=8
  c define: STC8G = 0, STC8H = 1, STC8A = 0
  c include: as above
target STC8A (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC8G = 0, STC8H = 0, STC8A = 1
  c include: ..\STC8H;.\STC8\lq_stc8;.\STC8\peripheral;.\STC8\test
